Commit message: REMOVE: unnecesary lauch files

File: models_pkg/models/shelf/shelf.urdf (robot description, URDF)
Before this commit: robot shelf_model, 1 links, 0 joints
Links:
- link shelf: mass 1.0 -> 100.0
